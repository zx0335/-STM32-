# Keil uVision project Template.uvprojx, settings and files
target template (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\HARDWARE;..\CORE;..\LIB\inc;..\USER;..\SYSTEM;..\Source\include;..\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/: key.c led.c dht11.c i2c.c oled.c esp8266.c malloc.c rtc.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c usart2.c
  group FreeRTOS_CORE
    ../Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../Source/portable/MemMang/: heap_4.c
    ../Source/portable/RVDS/ARM_CM4F/: port.c
  group LIB
    ../LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
